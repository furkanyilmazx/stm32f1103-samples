# Keil uVision project denemeProjesi.uvprojx, settings and files
target project-2 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: second-project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\2-02.11.2015;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\Utilities\STM32_EVAL\Common;.\Libraries\Utilities\STM32_EVAL
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group std_periph-source
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_usart.c stm32f10x_spi.c
  group std_periph-header
    ./Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_dbgmcu.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_gpio.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_tim.h
  group startup-source
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group user-source
    ./: system_stm32f10x.c main.c
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group user-header
    ./: stm32f10x_conf.h
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h stm32f10x.h
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h

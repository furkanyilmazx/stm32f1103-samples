# Keil uVision project VirtualCOMPort.uvprojx, settings and files
target touchy (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32_USB_TOUCHY +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\inc;.\Libraries_USB_STDLIB\CMSIS\Device\ST\STM32F10x\Include;.\Libraries_USB_STDLIB\STM32_USB-FS-Device_Driver\inc;.\Libraries_USB_STDLIB\STM32F10x_StdPeriph_Driver\inc;.\Libraries_USB_STDLIB\CMSIS\Include;.\Libraries_USB_STDLIB\CMSIS\Device\ST\STM32F10x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./src/: AD5932.c hw_config.c main.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group CMSIS
    ./Libraries_USB_STDLIB/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ./Libraries_USB_STDLIB/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_md.s
  group USB-FS-Device_Driver
    ./Libraries_USB_STDLIB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Driver
    ./Libraries_USB_STDLIB/STM32F10x_StdPeriph_Driver/src/: stm32f10x_exti.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
software components: CMSIS:CORE 4.3.0
